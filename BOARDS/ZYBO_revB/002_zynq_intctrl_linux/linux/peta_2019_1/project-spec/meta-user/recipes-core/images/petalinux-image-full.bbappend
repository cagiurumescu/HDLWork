#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " plirqdrv"
IMAGE_INSTALL_append = " plirqapp"
